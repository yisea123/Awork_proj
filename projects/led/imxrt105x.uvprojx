# Keil uVision project imxrt105x.uvprojx, settings and files
target Debug sdram (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Debug_sdram\imxrt105x.axf -o Objects\Debug_sdram\imxrt105x.srec
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_SDRAM
  c include: ..\..\aworks_sdk\apollo\interface\include;..\examples\peripheral;..\..\aworks_sdk\apollo\rtk\include;..\..\aworks_sdk\apollo\rtk\config;..\..\aworks_sdk\apollo\psp\rtk\include;..\..\aworks_sdk\apollo\psp\rtk\config;..\..\aworks_sdk\apollo\components\awbus_lite\include;..\..\aworks_sdk\apollo\components\awbus_lite\config;..\..\aworks_sdk\apollo\components\base\include;..\..\aworks_sdk\apollo\components\base\config;..\..\aworks_sdk\include\bsp;..\..\aworks_sdk\include\cpu;..\..\aworks_sdk\include;..\..\aworks_sdk\include\GUI;..\..\aworks_sdk\include\fs;..\..\aworks_sdk\include\config;..\..\aworks_sdk\apollo\3rdparty\net\lwip_1.4.x\src\include;..\..\aworks_sdk\apollo\3rdparty\net\lwip_1.4.x\src\include\ipv4;.\user_config;.\user_code;.\user_config\awbl_hwconf_usrcfg;.\user_config\emWin522_Config;..\img_rt1050_debug\user_config;..\img_rt1050_debug\user_config\awbl_hwconf_usrcfg;..\img_rt1050_debug\user_config\emWin522_Config;..\..\aworks_sdk\include\lora;..\..\aworks_sdk\include\awsa
  asm include: ..\examples\peripheral\sai
  library: MicroLIB
  scatter file: .\imxrt105x_sdram.sct
  link misc: --remove --entry=Reset_Handler --verbose
  group user_code
    ../img_rt1050_debug/user_code/: main.c
  group user_config
    ../img_rt1050_debug/user_config/: aw_prj_config.c aw_prj_param_auto_cfg.h aw_prj_params.h aw_prj_usr_app_init.c
    ./user_config/: flexram_config_for_armcc.S
  group awbl_hwconf_usrcfg
    ../img_rt1050_debug/user_config/awbl_hwconf_usrcfg/: awbl_hwconf_bu21029muv.h awbl_hwconf_buzzer_pwm.h awbl_hwconf_cyw43362.c awbl_hwconf_cyw43362_wifi_spi.h awbl_hwconf_emwin_fb.h awbl_hwconf_fm175xx_spi.h awbl_hwconf_ft5x06.h awbl_hwconf_generic_phy.h awbl_hwconf_gpio_i2c0.h awbl_hwconf_gpio_led.h awbl_hwconf_gpio_wdt.h awbl_hwconf_hw480272f.h awbl_hwconf_hw800480f.h awbl_hwconf_hwcap480272f.h awbl_hwconf_imx1050_acmp1.h awbl_hwconf_imx1050_adc1.h awbl_hwconf_imx1050_adc2.h awbl_hwconf_imx1050_edma.h awbl_hwconf_imx1050_eflex_pwm4.h awbl_hwconf_imx1050_enc1.h awbl_hwconf_imx1050_enet.h awbl_hwconf_imx1050_flexcan1.h awbl_hwconf_imx1050_flexcan2.h awbl_hwconf_imx1050_flexio2_uart0.h awbl_hwconf_imx1050_flexspi.h awbl_hwconf_imx1050_gpio.h awbl_hwconf_imx1050_gpt1.h awbl_hwconf_imx1050_gpt2.h awbl_hwconf_imx1050_lpi2c1.h awbl_hwconf_imx1050_lpi2c2.h awbl_hwconf_imx1050_lpspi1.h awbl_hwconf_imx1050_lpspi2.h awbl_hwconf_imx1050_lpspi3.h awbl_hwconf_imx1050_lpspi4.h awbl_hwconf_imx1050_lpuart1.h awbl_hwconf_imx1050_lpuart3.h awbl_hwconf_imx1050_mqs.h awbl_hwconf_imx1050_nandflash_mx30lf1g08.h awbl_hwconf_imx1050_nandflash_s34ml01g2.h awbl_hwconf_imx1050_nandflash_s34ml02g2.h awbl_hwconf_imx1050_nvic.h awbl_hwconf_imx1050_ocotp.h awbl_hwconf_imx1050_pit.h awbl_hwconf_imx1050_qtimer3_pwm.h awbl_hwconf_imx1050_rtwdt.h awbl_hwconf_imx1050_sai1.h awbl_hwconf_imx1050_sai3.h awbl_hwconf_imx1050_sdio_sd0.h awbl_hwconf_imx1050_semc.h awbl_hwconf_imx1050_tempmon.h awbl_hwconf_imx1050_ts.h awbl_hwconf_imx1050_usbd.h awbl_hwconf_imx1050_usbh1.h awbl_hwconf_imx1050_usbh2.h awbl_hwconf_imx1050_wdt1.h awbl_hwconf_pcf85063.h awbl_hwconf_spi_flash0.h awbus_lite_hwconf_usrcfg.c awbl_hwconf_sx127x.h awbl_hwconf_ov7725.h awbl_hwconf_imx1050_csi.h
  group emWin_Config
    ../img_rt1050_debug/user_config/emWin_Config/: GUI_X.c GUIConf.c LCDConf.c SIMConf.c
  group lib
    ../../aworks_sdk/lib/Release/: aworks_imx1050.lib
  group my_libc
    ./my_libc/: asctime_r.c strnlen.c detection.c heap.c gmtime_r.c
target Release sdram (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Release_sdram\imxrt105x.axf -o Objects\Release_sdram\imxrt105x.srec
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_SDRAM
  c include: as above
  asm include: ..\examples\peripheral\sai
  library: MicroLIB
  scatter file: .\imxrt105x_sdram.sct
  link misc: --remove --entry=Reset_Handler --verbose
target Debug flexspi flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Debug_flexspi_flash\imxrt105x.axf -o Objects\Debug_flexspi_flash\imxrt105x.srec
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_QSPI_FLASH
  c include: as above
  asm include: ..\examples\peripheral\sai
  library: MicroLIB
  scatter file: .\imxrt105x_flexspi_flash.sct
  link misc: --remove --entry=Reset_Handler --verbose
target Release flexspi flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Release_flexspi_flash\imxrt105x.axf -o Objects\Release_flexspi_flash\imxrt105x.srec
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_QSPI_FLASH
  c include: as above
  asm include: ..\examples\peripheral\sai
  library: MicroLIB
  scatter file: .\imxrt105x_flexspi_flash.sct
  link misc: --remove --entry=Reset_Handler --verbose
